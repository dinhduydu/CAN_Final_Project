<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CAN_Normal_Mode_2Nodes.ewp</path>
  </project>
  <batchBuild />
</workspace>
